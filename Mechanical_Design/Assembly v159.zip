# Autodesk Inventor part: ServoMountPlate
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: ServoMountPlate
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: ServoMountPlate
Author: Administrator
## Design history (mm, degrees)
feature "ServoMountPlate"
body "Solid1"
