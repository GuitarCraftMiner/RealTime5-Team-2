# Autodesk Inventor part: NacelleRear
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: NacelleRear
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: NacelleRear
Author: Administrator
## Design history (mm, degrees)
feature "NacelleRear"
body "Solid1"
