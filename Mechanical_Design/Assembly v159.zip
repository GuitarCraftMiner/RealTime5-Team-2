# Autodesk Inventor part: MotorMount1
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: MotorMount1
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: MotorMount1
Author: Administrator
## Design history (mm, degrees)
feature "MotorMount1"
body "Solid1"
