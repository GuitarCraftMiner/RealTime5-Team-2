# Autodesk Inventor part: BottomPlate
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: BottomPlate
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: BottomPlate
Author: Administrator
## Design history (mm, degrees)
feature "BottomPlate"
body "Solid1"
