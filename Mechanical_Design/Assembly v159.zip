# Autodesk Inventor part: Component5
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: Component5
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Component5
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
