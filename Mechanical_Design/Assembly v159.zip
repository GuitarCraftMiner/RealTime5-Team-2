# Autodesk Inventor part: NacelleFront
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: NacelleFront
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: NacelleFront
Author: Administrator
## Design history (mm, degrees)
feature "NacelleFront"
body "Solid1"
