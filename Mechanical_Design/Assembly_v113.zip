# Autodesk Inventor part: 20mmRod
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-02
Part Number: 20mmRod
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: 20mmRod v1
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
